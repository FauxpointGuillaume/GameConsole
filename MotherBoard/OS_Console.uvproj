# Keil uVision project OS_Console.uvproj, settings and files
target Simulation (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: template-project
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER STM32F40XX
  c include: .\app;.\boot;.\libraries;.\RTOS;.\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Boot
    ./boot/: system_stm32f4xx.c startup-rvds.s
  group Source
    ./src/: main.c global.c StreetOfRage.c Licorne.c
  group ST libraries
    ./libraries/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group app
    ./app/: buttons.c leds.c joystick.c potentiometer.c serial.c fsmc.c sd.c interface.c
  group SDIO
    ./SDIO/: diskio.c ff.c stm32f4_discovery.c stm32f4_discovery_sdio_sd.c stm32f4xx_it.c
target Reel (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: OS
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32F40XX
  c include: .\app;.\boot;.\libraries;.\RTOS;.\src;.\SDIO
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x60000000 size 0x6fffffff
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
